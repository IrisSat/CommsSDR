options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: telemetry_parser
    output_language: python
    run_options: run
    title: Telemetry parser component example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/jonathan/gr-satellites/satellite-recordings/tw_1b.wav
    repeat: 'False'
  states: {}
- name: satellites_ax100_deframer_0
  id: satellites_ax100_deframer
  parameters:
    mode: '"RS"'
    threshold: '0'
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '4800'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}
- name: satellites_telemetry_parser_0
  id: satellites_telemetry_parser
  parameters:
    definition: gomx_1
    file: /home/jonathan/CommsSDR/output/output_telemetry_parser.txt
    output: file
  states: {}

connections:
- [blocks_wavfile_source_0, '0', satellites_fsk_demodulator_0, '0']
- [satellites_ax100_deframer_0, out, satellites_telemetry_parser_0, in]
- [satellites_fsk_demodulator_0, '0', satellites_ax100_deframer_0, '0']

metadata:
  file_format: 1
