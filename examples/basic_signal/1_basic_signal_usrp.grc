options:
  parameters:
    generate_options: qt_gui
    id: basic_signal_zmq
    output_language: python
    title: Basic signal example with ZMQ
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/billdion/Documents/Workshop Tutorials/aausat_4.wav
    repeat: 'True'
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: file
    file: /home/billdion/Documents/Workshop Tutorials/AAUSAT-4.yml
    name: AAUSAT-4
    norad: '12345'
    samp_rate: samp_rate
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:50252
    timeout: '100'
    type: byte
  states: {}

connections:
- [blocks_pdu_to_tagged_stream_0, '0', zeromq_pub_sink_0, '0']
- [blocks_throttle_0, '0', satellites_satellite_decoder_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [satellites_satellite_decoder_0, out, blocks_message_debug_0_0_0, print_pdu]
- [satellites_satellite_decoder_0, out, blocks_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
