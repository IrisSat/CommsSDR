options:
  parameters:
    generate_options: qt_gui
    id: uplink_usrp
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '1234'
    src_zeros: 'False'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: ul_freq
    gain0: tx_gain
    samp_rate: 192e3
    sync: sync
    type: fc32
  states: {}
- name: ul_freq
  id: parameter
  parameters:
    type: eng_float
    value: 145.840e6
  states: {}

connections:
- [network_udp_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [network_udp_source_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
