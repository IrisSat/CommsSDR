options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: telemetry_parser
    output_language: python
    run_options: run
    title: Telemetry parser component example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/jonathan/CommsSDR/examples/satellite-recordings/us01.wav
    repeat: 'False'
  states: {}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '9600'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}

connections:
- [blocks_wavfile_source_0, '0', satellites_fsk_demodulator_0, '0']
- [satellites_ax25_deframer_0, out, blocks_message_debug_0, print_pdu]
- [satellites_fsk_demodulator_0, '0', satellites_ax25_deframer_0, '0']

metadata:
  file_format: 1
