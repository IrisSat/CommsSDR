options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: telemetry_parser
    output_language: python
    run_options: run
    title: Telemetry parser component example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/jonathan/gr-satellites/satellite-recordings/gomx_1.wav
    repeat: 'False'
  states: {}
- name: satellites_afsk_demodulator_0_0
  id: satellites_afsk_demodulator
  parameters:
    af_carrier: '3600'
    baudrate: '4800'
    deviation: '-1200'
    samp_rate: samp_rate
  states: {}
- name: satellites_telemetry_parser_0
  id: satellites_telemetry_parser
  parameters:
    definition: gomx_1
    file: /home/jonathan/CommsSDR/output/output_telemetry_parser.txt
    output: file
  states: {}
- name: satellites_u482c_deframer_0
  id: satellites_u482c_deframer
  parameters:
    threshold: '4'
  states: {}

connections:
- [blocks_wavfile_source_0, '0', satellites_afsk_demodulator_0_0, '0']
- [satellites_afsk_demodulator_0_0, '0', satellites_u482c_deframer_0, '0']
- [satellites_u482c_deframer_0, out, satellites_telemetry_parser_0, in]

metadata:
  file_format: 1
