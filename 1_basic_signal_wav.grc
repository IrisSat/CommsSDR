options:
  parameters:
    generate_options: qt_gui
    id: basic_signal_usrp
    output_language: python
    title: Basic signal example
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 437e6
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '20'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '71'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 1e6
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*decimation), samp_rate/(2*decimation), 10000)
    type: ccc
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: norad
    file: ./definitions/AISTECHSAT-3.yml
    iq: 'True'
    norad: '12345'
    samp_rate: samp_rate/decimation
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: center_freq
    dev_args: '""'
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:50252
    timeout: '100'
    type: byte
  states: {}

connections:
- [blocks_pdu_to_tagged_stream_0, '0', zeromq_pub_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', satellites_satellite_decoder_0, '0']
- [satellites_satellite_decoder_0, out, blocks_message_debug_0_0_0, print_pdu]
- [satellites_satellite_decoder_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
