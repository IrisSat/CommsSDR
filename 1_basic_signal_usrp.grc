options:
  parameters:
    generate_options: qt_gui
    id: basic_signal_zmq
    output_language: python
    title: Basic signal example with ZMQ
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/jonathan/Desktop/testrecording.wav
    type: complex
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/jonathan/CommsSDR/examples/basic_signal/aausat_4.wav
    repeat: 'False'
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: file
    file: /home/jonathan/CommsSDR/examples/basic_signal/AAUSAT-4.yml
    name: AAUSAT-4
    norad: '12345'
    samp_rate: samp_rate
  states: {}

connections:
- [blocks_pdu_to_tagged_stream_0, '0', blocks_throttle_0_0, '0']
- [blocks_throttle_0, '0', satellites_satellite_decoder_0, '0']
- [blocks_throttle_0_0, '0', blocks_file_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [satellites_satellite_decoder_0, out, blocks_message_debug_0_0_0, print_pdu]
- [satellites_satellite_decoder_0, out, blocks_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
