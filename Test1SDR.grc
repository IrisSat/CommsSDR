options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: center_freq
  id: parameter
  parameters:
    value: '145000000'
  states: {}
- name: decimation
  id: parameter
  parameters:
    value: '20'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: decimation
    samp_rate: samp_rate
    type: ccc
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: '1000000'
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: file
    file: /home/gnu/Documents/CommsSDR/IRIS.yml
    norad: ''
    samp_rate: samp_rate
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: rx_gain
    num_mboards: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [freq_xlating_fir_filter_xxx_0, '0', satellites_satellite_decoder_0, '0']
- [satellites_satellite_decoder_0, out, blocks_message_debug_0, print_pdu]
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
